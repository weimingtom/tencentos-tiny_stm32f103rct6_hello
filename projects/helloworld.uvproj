# Keil uVision project helloworld.uvproj, settings and files
target helloworld (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: helloworld +hex
  c flags: Optim=1
  c define: USE_HAL_DRIVER, STM32F103xE
  c include: ..\board\NUCLEO_STM32F103RB\BSP\Inc;..\platform\vendor_bsp\st\STM32F1xx_HAL_Driver\Inc;..\platform\vendor_bsp\st\STM32F1xx_HAL_Driver\Inc\Legacy;..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F1xx\Include;..\platform\vendor_bsp\st\CMSIS\Include;..\arch\arm\arm-v7m\common\include;..\arch\arm\arm-v7m\cortex-m3\armcc;..\kernel\core\include;..\kernel\pm\include;..\osal\cmsis_os;..\board\NUCLEO_STM32F103RB\TOS_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group projects
    ./: startup_stm32f10x_hd.s
  group board_NUCLEO_STM32F103RB_BSP_Src
    ../board/NUCLEO_STM32F103RB/BSP/Src/: gpio.c main.c mcu_init.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c usart.c
  group platform_STM32F1xx_HAL_Driver
    ../platform/vendor_bsp/st/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_utils.c stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c
  group arch_arm_arm-v7m_cortex-m3_armcc
    ../arch/arm/arm-v7m/cortex-m3/armcc/: port.h port_c.c port_config.h port_s.S
  group arch_arm_arm-v7m_common
    ../arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
  group kernel_core
    ../kernel/core/: tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c
  group osal_cmsis_os
    ../osal/cmsis_os/: cmsis_os.c cmsis_os.h
  group examples_hello_world
    ../examples/hello_world/: hello_world.c
  group board_NUCLEO_STM32F103RB_TOS_CONFIG
    ../board/NUCLEO_STM32F103RB/TOS_CONFIG/: tos_config.h
